File: KiCad/HB15.kicad_pcb (KiCad board)
At the start: 2 copper layers, 90 parts, among them J1 Line in, J2 Line out, SW1 On/Bypass

Commit message: KiCad6
Other:
- net class Default removed
